Commit message: 0724

File: urdf/peg_hole_gazebo/hole/urdf/new_hole.urdf (robot description, URDF)
Before this commit: robot new_hole, 1 links, 0 joints
Links:
- link hole: geometry collision mesh filename=../meshes/new_hole.STL; visual mesh filename=../meshes/new_hole.STL
